## config/boards/shields/ihatezmk/Kconfig.defconfig
```kconfig
if SHIELD_IHATEZMK

config ZMK_KEYBOARD_NAME
    default "ihatezmk"

endif # SHIELD_IHATEZMK
```
